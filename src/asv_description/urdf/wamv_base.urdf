Commit message: .

File: src/asv_description/urdf/wamv_base.urdf (robot description, URDF)
Before this commit: robot wam-v, 6 links, 5 joints
Links:
- link dummy_link_fix_mesh_origin: geometry collision box size=0.65 0.2 0.1; collision box size=0.65 0.2 0.1
